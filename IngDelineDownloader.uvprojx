# Keil uVision project IngDelineDownloader.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: ING91600 INGChips
  pack: INGChips.INGCHIPS_DeviceFamilyPack.0.9.0
  cpu: IROM(0x2000000-0x21fffff) IRAM(0x20000000-0x20007fff) CPUTYPE("Cortex-M4") FPU2 CLOCK(12800000) ELITTLE
  output: IngDelineDownloader +hex
  AfterMake: fromelf.exe --bin -o IngDelineDownloader.bin ./output/IngDelineDownloader.axf
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,POWER_SAVING,TEST_FAFTS,USE_HARD_IIC
  c misc: -Wno-invalid-source-encoding
  c include: ../../sdk/bundles/noos_mini/inc;../../sdk/bundles/noos_mini/inc/os;../../sdk/src/BSP;../../sdk/src/FWlib;../../sdk/src/StartUP/ing916;../../sdk/src/Tools;../../sdk/src;.\src;.\FreeRTOS;.\FreeRTOS\include;.\FreeRTOS\portable\RVDS\ARM_CM4F;.\FreeRTOS\portable\GCC\ARM_CM4F;.\FATFS\src;.\u8g2\csrc;.\src\minIni-master\dev
  library: MicroLIB
  memory RVCT4: ROM 0x2027000 size 0x59000
  memory RVCT5: ROM 0x4000000 size 0x1000000
  memory RVCT9: RAM 0x20004358 size 0x9ca8
  group APP
    ./src/: main.c profile.c port.c bsp_key.c bsp_msg.c bsp_qdec.c bsp_rtc.c bsp_timer.c bsp_usb_msc.c delay.c gui_menu.c qspi_flash.c use_fatfs.c use_u8g2.c uart_driver.c bsp_buzzer.c uart_buner.c ota_service.c bmp.c
    ./src/minIni-master/dev/: minIni.c
  group StartUP
    ./src/: startup_ing91600.s
    ../../sdk/bundles/noos_mini/ING9168xx/: symdefs.m
  group BSP
    ../../sdk/src/BSP/: eflash.c iic.c
  group FWlib
    ../../sdk/src/FWlib/: peripheral_adc.c peripheral_gpio.c peripheral_i2c.c peripheral_pinctrl.c peripheral_pwm.c peripheral_rtc.c peripheral_ssp.c peripheral_sysctrl.c peripheral_timer.c peripheral_uart.c peripheral_dma.c peripheral_pdm.c peripheral_qdec.c peripheral_usb.c
  group FreeRTOS
    ./FreeRTOS/: event_groups.c gen_os_impl.c list.c queue.c tasks.c timers.c
    ./FreeRTOS/portable/MemMang/: heap_4.c
  group Gui
    ./u8g2/csrc/: mui.c mui_u8g2.c u8g2_arc.c u8g2_bitmap.c u8g2_box.c u8g2_buffer.c u8g2_button.c u8g2_circle.c u8g2_cleardisplay.c u8g2_d_memory.c u8g2_d_setup.c u8g2_font.c u8g2_fonts.c u8g2_hvline.c u8g2_input_value.c u8g2_intersection.c u8g2_kerning.c u8g2_line.c u8g2_ll_hvline.c u8g2_message.c u8g2_polygon.c u8g2_selection_list.c u8g2_setup.c u8log.c u8log_u8g2.c u8log_u8x8.c u8x8_8x8.c u8x8_byte.c u8x8_cad.c u8x8_capture.c u8x8_d_sh1107.c u8x8_d_ssd1306_128x64_noname.c u8x8_debounce.c u8x8_display.c u8x8_fonts.c u8x8_gpio.c u8x8_input_value.c u8x8_message.c u8x8_selection_list.c u8x8_setup.c u8x8_string.c u8x8_u8toa.c u8x8_u16toa.c
  group Fatfs
    ./FATFS/src/: diskio.c ff.c ffsystem.c ffunicode.c
software components: CMSIS:CORE 4.3.0
